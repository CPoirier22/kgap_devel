# IAR project kt4585_gcc.ewp, settings and files
configuration GCC-target-wentworth (CR16C)
  GCC.CCIncludePaths: C:\Polycomdevel\tools\cr16-tools\lib\gcc\cr16-elf\4.1.2\include\
  GCC.CCDefines: SIZE_OF_NON_VOL_MEM=0x800; HEAP_SIZE=0x1D78; L2_PACKET_SIZE=0x80; UART_TX_BUFFERSIZE=0x300; UART_RX_BUFFERSIZE=0x100; RECORD_SIZE=0x80; MAX_Allowed_Users=10; LMX_4180; _SC14480_; __no_init=; __data24=; GCCCOMPILE; DUMMY -Wall -Os -fpack-struct -fno-strict-aliasing -mcr16cplus -mdata-model=far
  GCC.CCDiagSuppress: Pe061
  ACR16C.ADefines: PROM; MEMORY_MODEL_MEDIUM; _SC14402_; __CR16__; _LMX4169_; PORTABLE_PART__
  ACR16C.AIncludePaths: $TOOLKIT_DIR$\INC\
  ASC14.DspDerivative: SC14428-DSP
  ASC14.ADefines: as above
  group C
    mac/driver/src/: long_slot.c serialiotask.c frequency_sc14480.c
    application/kt4585/hlkgap/app/src/: fp_api.c pp_api.c mac_user_main.c user_main.c PPconnectionHandler.c FPconnectionHandler.c FPsubscriptionHandler.c FPMSFHandler.c
    application/api/src/: common_signalHandler.c gcc_specifics.c special_malloc_memory.c handle_gen_api_event.c ciss_state.c pp_application.c at_handler.c fp_application.c kt4585app_util.c kt4585app_app.c
    application/api/src/pp/: pp_msf.c
    application/api/src/general/: general_eeprom.c common_hardware.c
    application/api/src/fp/: fp_general.c fp_instance.c fp_msf.c fp_voice.c
    common/src/: glibc.c commondata.c app_util.c print_status.c
    mac/startup/src/: except.c gcc_handlers.c interrupts.c
    application/util/src/: common_tasks.c bits.c idle_loop_task.c mail_routing.c mail_recording.c bearer_trace.c stack_barrier.c quickdata.c controllerTask.c dduos_utils.c dduos_interface.c common_application.c random.c mac.c
    mac/driver/src/pp/: testmode_PP.c search_flag.c bmcdrivp.c sltbuild.c search.c hscsf.c hsllme.c hsccf.c bearerp.c
    mac/driver/src/common/: bmcdriv.c bearer.c
    mac/driver/src/fp/: fpslotsw.c bsllme.c fpsync.c bmcdrivf.c bmcdrivf6.c radio_status.c bsccf1g8.c bscsf.c bearerf.c
    os/src/: util.c os_tasks.c os.c os14480.c os_mail.c intmail.c mail_record.c os_timer.c os_timers.c
    machlinterface/src/pp/: kgaplink_pp.c ppmaclink.c
    machlinterface/src/fp/: kgaplink_fp.c fpmaclink.c
    machlinterface/src/: converter.c
    mac/eeprom/src/: f_eeprom_24lc16b.c ee.c eeutil.c ee_cache.c eetest.c
    mac/driver/src/fp/sc14480/: bmcdriv_14480.c
    application/480kernel/mac/src/: main.c bmc_prg.c bmc_serv.c bmc_prg6.c dipController.c lmx_calibrate.c version.c full.c mod_gain_calibration.c eeplayout.c eedeflt.c
    application/kt4585/hlkgap/app/src/dsp/: DSPSignalHandler.c gdsp_driver_functions.c gdsp_main.c gdsp_functionmanager_asm.c gdsp_functionmanager_impl.c gdsp_pp.c gdsp_fp.c gdsp_all_inits.c
    io/serial/src/STX_ETX/: l2.c
    io/serial/src/: rs232_hw_common.c rs232_tx_480.c rs232_rx_dma_480.c
    hlkgap/dduos/src/: dduos.c dduos_processid.c
    hlkgap/dduos/src/target/: heap428.c
    hlkgap/util/src/: print_signal.c memory.c bintree.c msgutil.c
    hlkgap/hlme/src/: f_hl_me.c
    hlkgap/gim/src/: gim.c
    hlkgap/app/src/: f_app_cc.c f_app_db.c f_app_om.c f_app_ss.c
    hlkgap/nwk/src/pp/: pccactive.c pccrel.c pccin.c ccpputil.c pccutil.c pccaction.c pccout.c pcc.c presresv.c plce.c pmmutil.c pmmstate.c pmm.c
    hlkgap/nwk/src/fp/: ccfputil.c fcc.c fccaction.c fccactive.c fccin.c fccout.c fccrel.c fccutil.c flce.c fmm.c fmmstate.c fmmutil.c fresresv.c
    hlkgap/nwk/src/: dsaa.c calc.c ciss.c mminstan.c fdb.c authen.c
    hlkgap/other/src/pp/: nvm.c
    hlkgap/dlc/src/pp/: ptlcrp.c ptlcop.c plb.c ptlchp.c ptlcas.c plc.c pllme.c plclow.c pclassaop.c plapc.c proute.c
    hlkgap/dlc/src/: faframe.c classaas.c ftlcas.c ftlchp.c ftlcrp.c lapclow.c
    hlkgap/common/src/: trees.c
    hlkgap/dlc/src/fp/: fclassaop.c flapc.c flb.c flc.c flclow.c froute.c
    hlkgap/iwu/src/pp/: piwucc.c piwudmm.c piwu.c piwuomm.c piwuaux.c
    hlkgap/iwu/src/fp/: fiwu.c fiwucc.c fiwuciss.c fiwudmm.c fiwuinst.c fiwuomm.c
    application/kt4585/hlkgap/app/src/wentworth/: call_button_control_pp.c page_button_control_pp.c volume_control_pp.c hex_to_decimal_sn_conv.c wentworth_pp.c wentworth_fp.c afe.c subscription_pp.c display_control_fp.c ashldi3.c ucmpdi2.c greeter.c second_base.c access_bus.c
    application/kt4585/hlkgap/app/src/sound/: sound.c sounds_wav.c
  group s
    application/480kernel/mac/src/: cstart.s
  group MAP
    application/480kernel/bin/list/: 480kernel.map
